Commit message: Target randomization

File: pioneer/envs/pioneer/assets/pioneer_knm_6dof.urdf (robot description, URDF)
Before this commit: robot pioneer, 13 links, 12 joints
Links:
- removed link target
Joints:
- removed joint world_to_target
